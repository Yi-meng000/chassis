# Keil uVision project Sekiro.uvprojx, settings and files
target Sekiro (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32H723ZETx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Sekiro +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c misc: --diag_suppress=1041
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../APL/Motor/inc;../FML/math/inc;../FML/basic/inc;../FML/Msg/inc;../FML/trajectory/inc;../APL/Chassis/inc;../APL/Sensor/inc;../APL/Actuator/inc;../BBL/Debug/inc;../BBL/Task/inc;../BBL/Trajectory/inc;../APL/Unitree/inc;../Sekiro/Match/inc;../Drivers/CMSIS/RTOS2/Include
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\stm32h723zxx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group FML/Msg
    ../FML/Msg/src/: IRQhandler.c FD_Canqueue.c
  group BBL/TASK
    ../BBL/Task/src/: myotask.c
  group BBL/Debug
    ../BBL/Debug/src/: DebugCtrl.c waveform.c
  group BBL/Trajectory
    ../BBL/Trajectory/src/: Trajectory.c Trajset.c
  group APL/Motor
    ../APL/Motor/src/: DJmotor.c VescMotor.c ZDrive.c
  group APL/Unitree
    ../APL/Unitree/src/: crc_ccitt.c gom_protocol.c my_Unitree.c
  group APL/Chassis
    ../APL/Chassis/src/: chassisPid.c chassisRun.c wheelTrain.c chassisComm.c
  group APL/Actuator
    ../APL/Actuator/src/: Actuator.c
  group APL/Sensor
    ../APL/Sensor/src/: relocation.c SensorCom.c kalman.c RadarMsg.c Cameracom.c
  group FML/Basic
    ../FML/basic/src/: LED.c
  group FML/Math
    ../FML/math/src/: mathFunc.c pid.c vector.c
  group Sekiro
    ../Sekiro/Match/src/: Sekiro.c MapRoute_com.c Match.c RobotCom.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 6.1.1, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
